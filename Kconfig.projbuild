## Kconfig.projbuild
```kconfig
menu "Component drv_version Configuration"

    config DRV_VERSION_USE
        bool "Use drv_version component"
        default y
        

endmenu
```
